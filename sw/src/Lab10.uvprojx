# Keil uVision project Lab10.uvprojx, settings and files
target Lab10 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab10
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PulseWidthMeasure.c Lab10.c PulseWidthMeasure.h Buttons.h Buttons.c Display.h Display.c Lab2Sensor.c Lab2Sensor.h Motor.h Motor.c
    ../inc/: PLL.c LaunchPad.c ST7735.c Timer0A.c Timer1A.c Timer0A.h Timer1A.h PWM.h PWM.c Timer2A.c Timer3A.c Timer2A.h Timer3A.h SysTick.c SysTick.h
software components: CMSIS:CORE 6.1.0
